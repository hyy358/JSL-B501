# Keil uVision project GSM.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: GSM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\UserSrc;.\StcLib;.\UserSrc\ENG
  group App
    ./: STARTUP.A51
    ./UserSrc/: main.c Driver.c LCD12864.c GSM.c NameList.c Eeprom.c SysStatus.c UnlockPassword.c SysString.c Card.c CardRead.c Audio.c
  group StcLib
    ./StcLib/: UART.C timer.c GPIO.c Exti.c spi.c
